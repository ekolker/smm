# Repository ekolker/smm

File README.md:

**[UNMAINTAINED] This library does not have a maintainer. The source code and repository will be kept at this URL indefinitely. If you'd like to help maintain this codebase, create an issue on this repo explaining why you'd like to become a maintainer and tag @tessel/maintainers in the body.**

smm
===

## KiCad design soil-moisture-module/soil-moisture-module.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C8: 100nF; SMD-0402
C2, C3: 10pF, DNP; SMD-0402
D1, D3: PMBD914,235; SOT-23
D2: LED; LED-0603
J1: MODULE_HEADER; MODULE_HEADER_MODULE
J2, J3, J4, J5: CONN_02X03; Pin_Header_Straight_2x03
Q1, Q2: 2N7002; SOT-23
R1, R5, R8: 10kR; SMD-0402
R2, R4, R7: 1kR; SMD-0402
R3, R6: 1MR; SMD-0402
U1: ATTINY24-SS; SOIC-14_N

Connections:
+3.3V: C1.1, J1.2 (3V3), J2.4, J3.4, R8.2, U1.1 (VCC)
/3.3V_PROBE_0: C7.1, J4.4, R7.2
/3.3V_PROBE_1: C6.1, J5.4, R2.2
/CLK: J1.5 (CLK), U1.9 ((PCINT4/USCK/SCL/T1/ADC4)PA4)
/CS: J1.8 (G1/TX), U1.5 ((PCINT10/CKOUT/OC0A/INT0)PB2)
/GND0: C2.2, C4.2, C7.2, J4.1, J4.5, Q2.2 (S), R3.1
/GND1: C3.2, C5.2, C6.2, J5.1, J5.5, Q1.2 (S), R6.1
/IRQ: J1.10 (G3), U1.3 ((PCINT9/XTAL2)PB1)
/LED: R4.2, U1.2 ((PCINT8/CLKI/XTAL1)PB0)
/LED_MID: D2.1 (A), R4.1
/LPF0_IN: J2.3, U1.12 ((PCINT1/AIN0/ADC1)PA1)
/LPF0_OUT: C2.1, D1.1, J4.3, R1.1
/LPF1_IN: J3.3, U1.10 ((PCINT3/T0/ADC3)PA3)
/LPF1_OUT: C3.1, D3.1, J5.3, R5.1
/MISO: J1.6 (MISO), U1.8 ((PCINT5/DO/MISO/OC1B/ADC5)PA5)
/MOSI: J1.7 (MOSI), U1.7 ((PCINT6/SDA/DI/MOSI/OC1A/ADC6)PA6)
/PD0_IN: J2.6, U1.13 ((PCINT0/AREF/ADC0)PA0)
/PD0_OUT: C4.1, D1.3, J4.6, R3.2
/PD1_IN: J3.6, U1.11 ((PCINT2/AIN1/ADC2)PA2)
/PD1_OUT: C5.1, D3.3, J5.6, R6.2
/WAVE_AMP_0: Q2.3 (D), R1.2, R7.1
/WAVE_AMP_1: Q1.3 (D), R2.1, R5.2
/WAVE_IN_0: J4.2, Q2.1 (G)
/WAVE_IN_1: J5.2, Q1.1 (G)
/WAVE_OUT: J2.2, J3.2, U1.6 ((PCINT7/ICP/OC0B/ADC7)PA7)
/~RESET: C8.1, J1.9 (G2/RX), R8.1, U1.4 ((PCINT11/dW/~RESET~)PB3)
GND: C1.2, C8.2, D2.2 (K), J1.1 (GND), J2.1, J2.5, J3.1, J3.5, U1.14 (GND)

Notes on the sheet:
C_TRACE
CABLE

Board: 2 copper layers, 116.8 x 27.9 mm, 27 parts (0 on the bottom side), 27 nets.

## Commit log

2014-11-19 first pass schematic
2014-11-19 first pass with "active" probes
2014-11-19 tricksy footprints...
2014-11-19 first pass layout; one probe "done"
2014-11-19 pinswap on PD diodes, second probe done. capacitances are approximate. ready to build, but next up is an experiment to maximize "edge" capacitance (at the expense of "substrate" capacitance).
2014-11-19 derp... the silk was swapped
2014-11-20 high-performance probe? we hope!
2014-11-20 so many polygons... super high performance probe? probably.
2014-11-20 gerbers for alpha build
2014-12-12 added cache lib just in case
2016-08-23 Adds unmaintained notice
